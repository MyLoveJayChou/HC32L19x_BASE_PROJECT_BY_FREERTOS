# Keil uVision project HC32L19X.uvprojx, settings and files
target HC32L19X_BASE (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: HC32L196PCTA HDSC
  pack: HDSC.HC32L19x.1.1.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: HC32L19X +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c include: ..\Core\Inc;..\Drivers\CMSIS\Core\Include;..\Drivers\CMSIS\Device\HDSC\HC32L19x\Include;..\Drivers\HC32L19x_HAL_Driver\Inc;..\Middlewares\SEGGER;..\Middlewares\EasyLogger\inc;..\Middlewares\SM4_CTR;..\Middlewares\FreeRTOS\Inc;..\BSP\OLED
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --keep=*Handler
  group Application/MDK-ARM
    ./: startup_hc32l19x.s
  group Application/User/Core
    ../Core/Src/: board.c main.c hc32l19x_it.c
  group BSP/OLED
    ../BSP/OLED/: bsp_oled_handler.c bsp_oled_driver.c bsp_display_wrapper.c bsp_display_port.c bsp_oled_text.c lvgl_font_port.c lv_font_cn_16.c lv_font_cn_14.c
  group Middlewares/FreeRTOS
    ../Middlewares/FreeRTOS/Src/: tasks.c queue.c list.c port.c heap_4.c event_groups.c stream_buffer.c timers.c croutine.c
  group Drivers/HC3219x_Driver
    ../Drivers/HC32L19x_HAL_Driver/Src/: adc.c adt.c aes.c bgr.c bt.c crc.c dac.c ddl.c debug.c dmac.c flash.c gpio.c i2c.c lcd.c lpm.c lptim.c lpuart.c lvd.c opa.c pca.c pcnt.c ram.c reset.c rtc.c spi.c sysctrl.c timer3.c trim.c trng.c uart.c vc.c wdt.c interrupts_hc32l19x.c
  group Drivers/CMSIS
    ../Core/Src/: system_hc32l19x.c
  group Middlewares/RTT
    ../Middlewares/SEGGER/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group Middlewares/EasyLogger
    ../Middlewares/EasyLogger/port/: elog_port.c
    ../Middlewares/EasyLogger/src/: elog.c elog_async.c elog_buf.c elog_utils.c
  group Middlewares/SM4_CTR
    ../Middlewares/SM4_CTR/: sm4_ctr.c
software components: CMSIS:CORE 5.6.0
